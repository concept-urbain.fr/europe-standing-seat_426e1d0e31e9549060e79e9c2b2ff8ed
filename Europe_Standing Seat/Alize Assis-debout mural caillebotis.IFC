Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Alize Assis-debout mural caillebotis.IFC
Time: 2020-07-01T08:25:53
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: MULT-MUL-004_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 14.6632; Area Measure: 1.22613; Volume Measure: 0.00190431
