Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Alize Assis-debout sur pieds composite.IFC
Time: 2020-07-01T08:27:32
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: EURO-ASS-SP-004_Default
In: Default Storey
Material: S 235

# IfcBeam: EUROALIZ-MULT-003_Default (2)
In: Default Storey
Material: 6060

# IfcBuildingElementProxy: EURO-ASS-COM-002_Default
In: Default Storey
Material: PE
PSet_Mass_Property - Mass Measure: 25.4062; Area Measure: 2.61838; Volume Measure: 0.0203799

# IfcBuildingElementProxy: EURO-ASS-SP-001_Default (2)
In: Default Storey
Material: 6060

# IfcBuildingElementProxy: EURO-ASS-SP-005_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: EUROALIZ-MULT-004_Default (2)
In: Default Storey
Material: AISI 304

# IfcBuildingElementProxy: EUROALIZ-MULT-005_Default (2)
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: EUROALIZ-MULT-008_Default (2)
In: Default Storey
Material: AZ10S8G

# IfcBuildingElementProxy: Tige filetée M12_Tige filetée M12 Assis debout banc ALIZE (2)
In: Default Storey
Material: S 235
