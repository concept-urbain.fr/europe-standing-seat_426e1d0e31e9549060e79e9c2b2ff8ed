Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Alize Assis-debout mural composite.IFC
Time: 2020-07-01T08:26:44
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: EURO-ASS-COM-002_Default
In: Default Storey
Material: PE

# IfcBuildingElementProxy: EURO-ASS-MUL-001_Default (2)
In: Default Storey
Name
EURO-ASS-MUL-001_Default | PSet_Mass_Property - Mass Measure: 18.8553; Area Measure: 1.08235; Volume Measure: 0.0183243
EURO-ASS-MUL-001_Default
